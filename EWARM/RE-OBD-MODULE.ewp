# IAR project RE-OBD-MODULE.ewp, settings and files
configuration RE-OBD-MODULE (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\Inc\Modules; ..\Inc\Inits; ..\Inc\Isr; ..\Inc\Sysclocks
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RE-OBD-MODULE.hex
  ILINK.IlinkOutputFile: RE-OBD-MODULE.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f407xx.s
  group Application/Inc/Inits
    ../Inc/Inits/: re_obd_gpio.h re_obd_init.h re_obd_uart.h re_obd_variables.h stm32f4xx_hal_conf.h
  group Application/Inc/Isr
    ../Inc/Isr/: re_obd_isr.h stm32f4xx_it.h
  group Application/Inc/Modules/main.h
    ../Inc/Modules/main/: main.h
  group Application/Inc/Modules/re_obd_battery1.h
    ../Inc/Modules/re_obd_battery1/: re_obd_battery1.h
  group Application/Inc/Modules/re_obd_battery2.h
    ../Inc/Modules/re_obd_battery2/: re_obd_battery2.h
  group Application/Inc/Modules/re_obd_battery3.h
    ../Inc/Modules/re_obd_battery3/: re_obd_battery3.h
  group Application/Inc/Modules/re_obd_battery4.h
    ../Inc/Modules/re_obd_battery4/: re_obd_battery4.h
  group Application/Inc/Modules/re_obd_check-reception.h
    ../Inc/Modules/re_obd_check_reception/: re_obd_check-reception.h
  group Application/Inc/Modules/re_obd_latch.h
    ../Inc/Modules/re_obd_latch/: re_obd_latch.h
  group Application/Inc/Modules/re_obd_modes.h
    ../Inc/Modules/re_obd_modes/: re_obd_modes.h
  group Application/Inc/Modules/re_obd_test.h
    ../Inc/Modules/re_obd_test/: re_obd_test.h
  group Application/Inc/Sysclocks
    ../Inc/Sysclocks/: re_obd_sysclock.h
  group Application/src/Inits
    ../Src/Inits/: re_obd_gpio.c re_obd_init.c re_obd_uart.c re_obd_variables.c stm32f4xx_hal_msp.c
  group Application/src/Isr
    ../Src/Isr/: re_obd_isr.c stm32f4xx_it.c
  group Application/src/Modules/main.c
    ../Src/Modules/main/: main.c
  group Application/src/Modules/re_obd_battery1.c
    ../Src/Modules/re_obd_battery1/: re_obd_battery1.c
  group Application/src/Modules/re_obd_battery2.c
    ../Src/Modules/re_obd_battery2/: re_obd_battery2.c
  group Application/src/Modules/re_obd_battery3.c
    ../Src/Modules/re_obd_battery3/: re_obd_battery3.c
  group Application/src/Modules/re_obd_battery4.c
    ../Src/Modules/re_obd_battery4/: re_obd_battery4.c
  group Application/src/Modules/re_obd_check-reception.c
    ../Src/Modules/re_obd_check_reception/: re_obd_check-reception.c
  group Application/src/Modules/re_obd_latch.c
    ../Src/Modules/re_obd_latch/: re_obd_latch.c
  group Application/src/Modules/re_obd_modes.c
    ../Src/Modules/re_obd_modes/: re_obd_modes.c
  group Application/src/Modules/re_obd_test.c
    ../Src/Modules/re_obd_test/: re_obd_test.c
  group Application/src/Sysclocks
    ../Src/Sysclocks/: re_obd_sysclock.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
